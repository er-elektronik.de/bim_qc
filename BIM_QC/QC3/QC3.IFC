Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: QC3.IFC
Time: 2023-04-27T06:09:26
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: QC Deckel BIM_QC 3 Deckel BIM
In: Default Storey
Material: ALMg3
SolidWorks Custom Properties - Material: ALMg3; Gewicht: 1449.56

# IfcBuildingElementProxy: QC Haube BIM_915790420 QC3 Haube
In: Default Storey
Material: Acrylglas
SolidWorks Custom Properties - Material: Acrylglas; Version 4: 00 - Ohne Piktogramm - unbeschriftet; Version 1: 20C1 - QC1 Piktogramm LMR/L/O DIN 7010; Version 2: 20C2 - QC2 Piktogramm LMR/L/O DIN 7010; Version 3: 20C3 - QC3 Piktogramm LMR/L/O DIN 7010; Gewicht: 5442.80

# IfcBuildingElementProxy: QC2_3 Leuchtmittel BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: 9W4 - LED 9W > 700Lm 4000K CR>80

# IfcElementAssembly: QC3
In: Default Storey
SolidWorks Custom Properties - Gewicht: 6918.88
PSet_Mass_Property - Mass Measure: 6.91888; Area Measure: 4.14339 m2; Volume Measure: 0.00509906 m3
