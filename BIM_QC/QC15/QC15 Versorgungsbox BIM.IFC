Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: QC15 Versorgungsbox BIM.IFC
Time: 2023-04-27T08:13:06
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Montagefläche_400x300
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Verrundung1
In: Default Storey
SolidWorks Custom Properties - Material: PC; Gewicht: 291.33; Version 1: AX - AUTOTEST DS&BS DL Schalt. 1/2W; Version 2: C - zentr. Vers. Funktionsüberwacht; Version 3: E - zentrale Versorgung AC/DC

# IfcBuildingElementProxy: Verrundung2
In: Default Storey
SolidWorks Custom Properties - Material: PC; Gewicht: 291.33; Version 1: AX - AUTOTEST DS&BS DL Schalt. 1/2W; Version 2: C - zentr. Vers. Funktionsüberwacht; Version 3: E - zentrale Versorgung AC/DC

# IfcElementAssembly: QC15 Versorgungsbox BIM
In: Default Storey
PSet_Mass_Property - Mass Measure: 0.351334; Area Measure: 0.407913 m2; Volume Measure: 0.000304819 m3
