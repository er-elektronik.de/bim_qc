Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: QC25_35 Versorgungsbox BIM.IFC
Time: 2023-04-27T08:18:22
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Montagefläche_400x300
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Verrundung1
In: Default Storey
SolidWorks Custom Properties - Material: PC; Gewicht: 502.05; Version 1: C- zentr. Vers. Funktionsüberwacht; Version 2: E - zentrale Versorgung AC/DC; Version 3: M - AUTOTEST,DS&BSDL-Schalt.3/5W

# IfcBuildingElementProxy: Verrundung2
In: Default Storey
SolidWorks Custom Properties - Material: PC; Gewicht: 502.05; Version 1: C- zentr. Vers. Funktionsüberwacht; Version 2: E - zentrale Versorgung AC/DC; Version 3: M - AUTOTEST,DS&BSDL-Schalt.3/5W

# IfcElementAssembly: QC25_35 Versorgungsbox BIM
In: Default Storey
PSet_Mass_Property - Mass Measure: 0.56205; Area Measure: 0.527449 m2; Volume Measure: 0.000481891 m3
