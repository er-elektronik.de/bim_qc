Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: QC13 Versorgungsbox BIM.IFC
Time: 2023-04-27T07:51:14
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Montagefläche_400x300
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Oberschale E-Box BIM_660011100 Oberschale E-Box weiß
In: Default Storey
SolidWorks Custom Properties - Material: PBTP; Gewicht: 94.51

# IfcBuildingElementProxy: Unterschale E-Box BIM
In: Default Storey
SolidWorks Custom Properties - Material: PBTP; Gewicht: 105.70

# IfcElementAssembly: QC13 Versorgungsbox BIM
In: Default Storey
PSet_Mass_Property - Mass Measure: 0.260213; Area Measure: 0.39901 m2; Volume Measure: 0.000212835 m3

# IfcElementAssembly: QC13 Versorgungsbox BIM_QC13 Versorgungsbox
In: Default Storey
SolidWorks Custom Properties - Gewicht: 200.21; Version 1: AX - AUTOTEST DS&BS DL Schalt. 1/2W; Version 2: C - zentr. Ver. Funktionsüberwacht; Version 3: E - zentrale Versorgung AC/DC
