Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: QC1.IFC
Time: 2023-04-27T06:03:21
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: QC Deckel BIM_QC 1 Deckel BIM
In: Default Storey
Material: ALMg3
SolidWorks Custom Properties - Material: ALMg3; Gewicht: 183.97

# IfcBuildingElementProxy: QC Haube BIM_915790400 QC 1 Haube
In: Default Storey
Material: Acrylglas
SolidWorks Custom Properties - Material: Acrylglas; Version 4: 00 - Ohne Piktogramm - unbeschriftet; Version 1: 20C1 - QC1 Piktogramm LMR/L/O DIN 7010; Version 2: 20C2 - QC2 Piktogramm LMR/L/O DIN 7010; Version 3: 20C3 - QC3 Piktogramm LMR/L/O DIN 7010; Gewicht: 621.52

# IfcBuildingElementProxy: QC1 LED Streifen BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: LN - LED 2W 4000K BLF100%

# IfcElementAssembly: QC1
In: Default Storey
SolidWorks Custom Properties - Gewicht: 808.98
PSet_Mass_Property - Mass Measure: 0.808978; Area Measure: 0.490607 m2; Volume Measure: 0.000589556 m3
